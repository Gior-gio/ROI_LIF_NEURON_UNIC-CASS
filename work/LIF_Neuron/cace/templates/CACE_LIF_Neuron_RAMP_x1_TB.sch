** sch_path: work/LIF_Neuron/cace/templates/CACE_LIF_Neuron_RAMP_x1_TB.sch
**.subckt CACE_LIF_Neuron_RAMP_x1_TB
VRESET net1 GND pwl 0 CACE{VDD} 10n CACE{VDD} 20n 0
VSP net4 GND CACE{VDD}
VSN net3 GND {VSS}
VR net2 GND {vref}
VC net5 GND pwl 0 {vref} 95n {vref} 105n {vctr}
R3 net5 Vctr 50 m=1
R4 net1 RST 50 m=1
R5 net2 Vref 50 m=1
R6 net3 VSS 50 m=1
R7 net4 VDD 50 m=1
RIN1 Vctr Vx 100k ac=1k m=1
C1 SPIKE VSS {cap} m=1
xLIF VDD Vx MEM RST SPIKE VSS Vref LIF_neuron
**** begin user architecture code



.param VDD = CACE{VDD}
.param VSS = 0
.param vctr = 0.6
.param vref = 1.2
.param cap = 0.1p

.save all

.control

* >> Variables <<
let Vhigh = CACE{VDD}
let Vmid = Vhigh * 0.5

let tstop = 0.2u
let tstep = tstop/10k

* Run transient analysis
tran $&tstep $&tstop

let IDD = -1*i(VSP)
meas tran I_avg AVG IDD from=tstep to=tstop
let P_avg = abs(I_avg*Vhigh)

meas TRAN T_spk TRIG v(SPIKE) VAL=Vmid rise=3 TARG v(SPIKE) VAL=Vmid rise=4
let F_spk = 1 / T_spk
let E_spk = P_avg/F_spk*1e12

echo $&F_spk $&I_avg $&P_avg $&E_spk> CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib CACE{corner_mos}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib CACE{corner_res}
.include CACE{DUT_path}

.temp CACE{temperature}

* Statitical switches
.param mm_ok=CACE{stat_sw}
.param mc_ok=CACE{stat_sw}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1

**** end user architecture code
**.ends
.GLOBAL GND
.end
